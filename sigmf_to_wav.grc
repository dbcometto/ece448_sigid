options:
  parameters:
    author: C25Dante.Cometto
    generate_options: qt_gui
    id: sigmf_to_wav
    output_language: python
    title: SigMF to Wav
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\workspace\ece448_sigid\data\sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\workspace\ece448_sigid\data\sigid.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
